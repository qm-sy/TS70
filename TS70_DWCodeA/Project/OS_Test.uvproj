# Keil uVision project OS_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: OS_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BSP\Inc;..\Core\Inc;..\Driver;..\SYSTEM;..\Emembed\Inc
  group Drivers
    ../Driver/: T5LOS8051.h
  group Core
    ./: main.c STARTUP_M5.A51
    ../Core/Src/: tim.c uart.c gpio.c
  group BSP
    ../BSP/Src/: communication.c
  group SYSTEM
    ../SYSTEM/: sys.c
  group Emembed
    ../Emembed/Src/: gui_ctrl.c modbus.c
